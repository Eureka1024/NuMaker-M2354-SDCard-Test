# Keil uVision project project.uvprojx, settings and files
target rtthread-m2354 (6160000::V6.16::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;board;board\NuClockConfig;board\NuPinConfig;..\libraries\m2354\CMSIS\Include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m23;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\m2354\Device\Nuvoton\M2354\Include;..\libraries\m2354\rtt_port;packages\fal-latest\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\m2354\StdDriver\inc;..\libraries\m2354\USBHostLib\inc;packages\netutils-latest\ntp;..\libraries\nu_packages\Demo;..\libraries\nu_packages\SLCD;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\io;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\..\..\components\utilities\utest;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\m2354_flash.sct
  group Applications
    applications/: mnt.c main.c
    ./applications/: readspeed.c writespeed.c
  group AT
    ../../../components/net/at/src/: at_cli.c at_utils.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    board/NuClockConfig/: nutool_modclkcfg.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/audio/: audio_pipe.c audio.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_crc.c hw_hash.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/src/: workqueue.c dataqueue.c ringblk_buf.c waitqueue.c completion.c pipe.c ringbuffer.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/m2354/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
    ../libraries/m2354/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../libraries/m2354/rtt_port/: drv_bpwm_capture.c drv_uuart.c drv_spi.c drv_gpio.c drv_wdt.c drv_spii2s.c drv_i2c.c drv_clk.c drv_timer.c drv_i2s.c drv_common.c drv_tpwm.c drv_otg.c drv_crc.c drv_timer_capture.c drv_pdma.c drv_crypto.c drv_qei.c drv_eadc.c drv_trng.c drv_qspi.c drv_ebi.c drv_uart.c drv_rtc.c drv_ecap.c drv_ui2c.c drv_scuart.c drv_epwm.c drv_usbd.c drv_sdh.c drv_fmc.c drv_usbhost.c drv_bpwm.c drv_slcd.c drv_epwm_capture.c drv_uspi.c drv_can.c drv_softi2c.c
  group fal
    packages/fal-latest/src/: fal_rtt.c fal_partition.c fal_flash.c fal.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ffunicode.c dfs_elm.c ff.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: kservice.c idle.c object.c timer.c components.c irq.c device.c signal.c mem.c thread.c ipc.c clock.c mempool.c scheduler.c
  group libc
    ../../../components/libc/compilers/armlibc/: mem_std.c syscalls.c libc_syms.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../libraries/m2354/StdDriver/src/: nu_spi.c nu_rtc.c nu_eadc.c nu_lcd.c nu_ebi.c nu_pdma.c nu_timer_pwm.c nu_ecap.c nu_qei.c nu_epwm.c nu_qspi.c nu_wwdt.c nu_wdt.c nu_ewdt.c nu_acmp.c nu_timer.c nu_sys.c nu_sdh.c nu_sc.c nu_ewwdt.c nu_rng.c nu_bpwm.c nu_fmc.c nu_can.c nu_usci_uart.c nu_fvc.c nu_clk.c nu_gpio.c nu_scuart.c nu_crc.c nu_usci_i2c.c nu_i2c.c nu_crypto.c nu_i2s.c nu_dac.c nu_usci_spi.c nu_usbd.c nu_uart.c nu_tamper.c nu_keystore.c nu_dpm.c
  group m2354_usbhostlib
    ../libraries/m2354/USBHostLib/src/: mem_alloc.c ohci.c usb_core.c
  group NetUtils
    packages/netutils-latest/iperf/: iperf.c
    packages/netutils-latest/ntp/: ntp.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_slcd
    ../libraries/nu_packages/SLCD/: slcd_rhe6616tp01.c
  group POSIX
    ../../../components/libc/posix/io/: select.c
    ../../../components/libc/posix/io/poll/: poll.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    ../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/src/: sal_socket.c
  group Sensors
    ../../../components/drivers/sensors/: sensor_cmd.c sensor.c
  group UTest
    ../../../components/utilities/utest/: utest.c
